# Keil uVision project spi.uvproj, settings and files
target LED Matrix (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: spi
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_LD_VL USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .;..\stm-software\stm32f10x_stdperiph_lib\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc;..\stm-software\stm32f10x_stdperiph_lib\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\stm-software\stm32f10x_stdperiph_lib\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ./: startup_stm32f10x_md_vl.s
    ../stm-software/stm32f10x_stdperiph_lib/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Source
    ./: led_matrix.c stm32f10x_conf.h
  group STM-standard peripheral library
    ../stm-software/stm32f10x_stdperiph_lib/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_spi.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_adc.c
